# Keil uVision project ADV.uvprojx, settings and files
target ADV (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L051C8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: ADV +hex
  AfterMake: fromelf --bin --output ./ADV/IAD_APP.bin ./ADV/ADV.axf
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32L051xx,USER_VECT_TAB_ADDRESS
  c include: ../Core/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../Drivers/CMSIS/Include;../HARDWARE/control;../HARDWARE/OLED;../HARDWARE/KEY;../HARDWARE/PCF8563;../HARDWARE/STMFLASH;../HARDWARE/bsp_cpu_flash;../HARDWARE/CMD;../HARDWARE/MUTI_MENU;../HARDWARE/LOW_POWER_RUN;..\HARDWARE\MAX17048;..\HARDWARE\MEASURE_TEST;..\HARDWARE\BUZZER;..\HARDWARE\BATTERY;..\HARDWARE\TIMING_MODE;..\HARDWARE\DOSE_RATE;..\HARDWARE;..\UI_MENU;..\HARDWARE\beep
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1000
  memory RVCT5: ROM 0x8001000 size 0xf000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/User/Core
    ../Core/Src/: main.c gpio.c lptim.c tim.c usart.c stm32l0xx_it.c stm32l0xx_hal_msp.c spi.c adc.c iwdg.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_cortex.c stm32l0xx_hal_exti.c stm32l0xx_hal_lptim.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_adc.c stm32l0xx_hal_iwdg.c
  group Drivers/CMSIS
    ./: startup_stm32l051xx.s
    ../Core/Src/: system_stm32l0xx.c
  group HARDWARE
    ../HARDWARE/control/: control.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/PCF8563/: myiic.c pcf8563.c
    ../HARDWARE/STMFLASH/: stm_flash.c
    ../HARDWARE/MAX17048/: max17048.c
    ../HARDWARE/OLED/: oled.c oled_data.c oled_rtc_time.c oled_set_val.c oledfont.c
    ../HARDWARE/BATTERY/: battery_ctr.c
    ../HARDWARE/CMD/: cmd.c
    ../HARDWARE/MUTI_MENU/: muti_menu.c
    ../HARDWARE/LOW_POWER_RUN/: low_power_run.c
    ../HARDWARE/TIMING_MODE/: timing_mode.c
    ../HARDWARE/DOSE_RATE/: dose_rate.c
    ../HARDWARE/: sys_ctr.c
    ../HARDWARE/beep/: beep.c
  group UI_MENU
    ../UI_MENU/: ui_menu.c
software components: CMSIS:CORE 4.3.0
