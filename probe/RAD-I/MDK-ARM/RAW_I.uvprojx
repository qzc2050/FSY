# Keil uVision project RAW_I.uvprojx, settings and files
target RAW_I (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: RAW_I +hex
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H743xx,USE_USB_FS
  c misc: --locale=english
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;..\HARDWARE\WS2812B;..\HARDWARE\CMD;..\HARDWARE\DATA_MANAGER;..\dev_protocol;..\HARDWARE\W25QXX;..\HARDWARE\PCF8563;..\HARDWARE\LCD;..\HARDWARE\W5500;..\FreeRTOS;..\FreeRTOS\include;..\FreeRTOS\portable;..\HARDWARE\ENS160;..\HARDWARE\BME280;..\HARDWARE\AHT20;..\HARDWARE\GEIGER;..\HARDWARE\JOYSTICK;..\LVGL\src;..\LVGL\src\porting;..\LVGL;..\LVGL\demos\stress;..\LVGL\demos;..\LVGL\app;..\FreeRTOS\APP;..\USB\STM32_USB_Device_Library\Core\Inc;..\USB\STM32_USB_Device_Library\Class\MSC\Inc;..\USB\USB_APP;..\HARDWARE\W5500\WIZnet;..\HARDWARE\PM2_5;..\HARDWARE\KEY;..\HARDWARE\beep;..\HARDWARE\STM_FLASH;..\HARDWARE\LORA;..\HARDWARE\DOSE_RATE
  memory RVCT4: ROM 0x8020000 size 0xe0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\ex_sdram.sct
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c fdcan.c fmc.c i2c.c ltdc.c quadspi.c spi.c tim.c usart.c usb_otg.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_ll_fmc.c stm32h7xx_hal_nor.c stm32h7xx_hal_sram.c stm32h7xx_hal_nand.c stm32h7xx_hal_sdram.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_dsi.c stm32h7xx_hal_qspi.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group HARDWARE
    ../HARDWARE/WS2812B/: ws2812b.c
    ../HARDWARE/CMD/: cmd.c
    ../HARDWARE/DATA_MANAGER/: device_config.c flash_fs_mutex.c data_manager_example.c dm_core.c dm_flash_backend.c hist_record_format.c hist_record_app.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/PCF8563/: pcf8563.c
    ../HARDWARE/LCD/: lcd_rgb.c
    ../HARDWARE/ENS160/: ENS160.c
    ../HARDWARE/BME280/: bme280.c BME280_app.c
    ../HARDWARE/AHT20/: AHT20.c
    ../HARDWARE/GEIGER/: geiger.c
    ../HARDWARE/JOYSTICK/: joystick.c
    ../HARDWARE/PM2_5/: pm2_5.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/beep/: beep.c
    ../HARDWARE/STM_FLASH/: reg_flash.c
    ../HARDWARE/DOSE_RATE/: dose_rate.c
  group W5500
    ../HARDWARE/W5500/: config.h device.c socket.c spi.c w5500.c network_cmd.c w5500_dhcp.c
    ../HARDWARE/W5500/WIZnet/: dhcp.c
  group LORA
    ../HARDWARE/LORA/: lora.c
  group DEV_PROTOCOL
    ../dev_protocol/core/: dev_malloc.c dev_protocol.c dev_queue.c
  group DEV_PROTOCOL/NET
    ../dev_protocol/net_raw/: net_raw_app.c net_raw_bsp.c net_raw_protocol.c
  group FREERTOS/APP
    ../FreeRTOS/APP/: freertos_app.c env_monitor.c
  group FREERTOS/CORE
    ../FreeRTOS/: FreeRTOSConfig.h croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FREERTOS/PORT
    ../FreeRTOS/portable/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group LVGL/APP
    ../LVGL/src/: lv_conf_internal.h
    ../LVGL/app/: ui.c ui_helpers.c ui_events.c language.c
    ../LVGL/app/components/: ui_comp.c ui_comp_hook.c ui_comp_mainmenu.c
    ../LVGL/app/fonts/: ui_font_hansanbold24.c ui_font_hansanbold28.c ui_font_hansanbold32.c ui_font_hansanbold36.c ui_font_hansanbold48.c ui_font_hansanbold64.c ui_font_hansanbold128.c
    ../LVGL/app/images/: ui_img_182239421.c ui_img_373985928.c ui_img_532493655.c ui_img_545021016.c ui_img_602667123.c ui_img_820325126.c ui_img_834997458.c ui_img_966723152.c ui_img_1261263291.c ui_img_1464373361.c ui_img_1523901040.c ui_img_1640302447.c ui_img_1777030953.c ui_img_1779444627.c ui_img_1957260177.c ui_img_1985833602.c ui_img_2138131786.c ui_img_display_png.c ui_img_pm2_5_png.c
    ../LVGL/app/screens/: ui_Main_Interface.c ui_Start_interface.c
  group LVGL/PORTING
    ../LVGL/src/porting/: lv_port_disp.c lv_port_indev.c
    ../LVGL/: lvgl.h
  group LVGL/CORE
    ../LVGL/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group LVGL/DRAW
    ../LVGL/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../LVGL/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../LVGL/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
  group LVGL/EXTRA
    ../LVGL/src/extra/layouts/flex/: lv_flex.c
    ../LVGL/src/extra/layouts/grid/: lv_grid.c
    ../LVGL/src/extra/libs/bmp/: lv_bmp.c
    ../LVGL/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../LVGL/src/extra/libs/freetype/: lv_freetype.c
    ../LVGL/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../LVGL/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../LVGL/src/extra/libs/png/: lodepng.c lv_png.c
    ../LVGL/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../LVGL/src/extra/libs/rlottie/: lv_rlottie.c
    ../LVGL/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../LVGL/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    ../LVGL/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../LVGL/src/extra/others/gridnav/: lv_gridnav.c
    ../LVGL/src/extra/others/ime/: lv_ime_pinyin.c
    ../LVGL/src/extra/others/imgfont/: lv_imgfont.c
    ../LVGL/src/extra/others/monkey/: lv_monkey.c
    ../LVGL/src/extra/others/msg/: lv_msg.c
    ../LVGL/src/extra/others/snapshot/: lv_snapshot.c
    ../LVGL/src/extra/themes/basic/: lv_theme_basic.c
    ../LVGL/src/extra/themes/default/: lv_theme_default.c
    ../LVGL/src/extra/themes/mono/: lv_theme_mono.c
    ../LVGL/src/extra/widgets/animimg/: lv_animimg.c
    ../LVGL/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../LVGL/src/extra/widgets/chart/: lv_chart.c
    ../LVGL/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../LVGL/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../LVGL/src/extra/widgets/keyboard/: lv_keyboard.c
    ../LVGL/src/extra/widgets/led/: lv_led.c
    ../LVGL/src/extra/widgets/list/: lv_list.c
    ../LVGL/src/extra/widgets/menu/: lv_menu.c
    ../LVGL/src/extra/widgets/meter/: lv_meter.c
    ../LVGL/src/extra/widgets/msgbox/: lv_msgbox.c
    ../LVGL/src/extra/widgets/span/: lv_span.c
    ../LVGL/src/extra/widgets/spinbox/: lv_spinbox.c
    ../LVGL/src/extra/widgets/spinner/: lv_spinner.c
    ../LVGL/src/extra/widgets/tabview/: lv_tabview.c
    ../LVGL/src/extra/widgets/tileview/: lv_tileview.c
    ../LVGL/src/extra/widgets/win/: lv_win.c
    ../LVGL/src/extra/: lv_extra.c
  group LVGL/FONT
    ../LVGL/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group LVGL/HAL
    ../LVGL/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group LVGL/MISC
    ../LVGL/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group LVGL/WIDGETS
    ../LVGL/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group LVGL/DEMO/STRESS
    ../LVGL/demos/stress/: lv_demo_stress.c
  group LVGL/DEMO/KEYPAD
    ../LVGL/demos/keypad_encoder/: lv_demo_keypad_encoder.c
  group USB_DEVICE
    ../USB/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
  group USB_CORE
    ../USB/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group USB_APP
    ../USB/USB_APP/: usbd_conf.c usbd_desc.c usbd_storage.c
software components: CMSIS:CORE 5.5.0
